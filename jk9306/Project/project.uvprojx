# Keil uVision project project.uvprojx, settings and files
target Open1788 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1788 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\emWin\Config;..\emWin\Header;..\emWin\Library;..\User\LCD;..\User\UseDisp;..\Libraries\Drivers\include;..\User\Test;..\Libraries\Drivers\include;..\User\Globalvalue;..\User\EX_SDRAM;..\User;..\User\CH421;..\emWin\Config;..\emWin\Header;..\emWin\Library;..\Libraries\Core\CM3\DeviceSupport\NXP\LPC177x_8x;..\User\ZiKu;..\Modubus;..\User\Key;..\Libraries\Core\CM3\CoreSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group User
    ../User/: main.c timer.c Page.C Page.H set_manu.c
    ../User/LCD/: lpc177x_8x_lcd.c logo.c AsciiLib.c lpc177x_8x_lcd.h
    ../User/TouchPanel/: TouchPanel.c
    ../User/UseDisp/: use_disp.c
    ../User/Key/: key.c
    ../User/Test/: test.c
    ../User/Globalvalue/: GlobalValue.c
    ../Libraries/Drivers/source/: lpc177x_8x_rtc.c
    ../User/EX_SDRAM/: EX_SDRAM.c
  group Startup
    ../Libraries/Core/CM3/DeviceSupport/NXP/LPC177x_8x/startup/arm/: startup_LPC177x_8x.s
  group CMSIS-CMS
    ../Libraries/Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
    ../Libraries/Core/CM3/CoreSupport/: core_cm3.c
  group Drivers
    ../Libraries/Drivers/source/: lpc177x_8x_gpio.c lpc177x_8x_systick.c lpc177x_8x_clkpwr.c lpc177x_8x_ssp.c lpc177x_8x_uart.c debug_frmwrk.c lpc177x_8x_eeprom.c lpc177x_8x_pinsel.c
  group emWin/Config
    ../emWin/Config/: GUI_X.c GUIConf.c GUIConf.h LCDConf.c LCDConf.h SIMConf.c
  group emWin/Library
    ../emWin/Library/: GUI_CM3.lib
  group emWin/Header
    ../emWin/Header/: BUTTON.h CHECKBOX.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h EDIT.h FRAMEWIN.h Global.h GRAPH.h GUI.h GUI_ARRAY.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_HOOK.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_Generic.h GUIDRV_IST3088.h GUIDRV_Lin.h GUIDRV_NoOpt_1_8.h GUIDRV_S1D15G00.h GUIDRV_S1D13748.h GUIDRV_SLin.h GUIDRV_SPage.h GUIDRV_SSD1926.h GUIDRV_Template.h GUIDRV_TemplateI.h HEADER.h ICONVIEW.h IMAGE.h LCD.h LCD_ConfDefaults.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTVIEW.h LISTWHEEL.h MENU.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h PROGBAR.h RADIO.h SCROLLBAR.h SLIDER.h SPINBOX.h TEXT.h TREEVIEW.h WIDGET.h WM.h WM_GUI.h WM_Intern.h
  group Modbus
    ../Modubus/: modbus_slave.c
